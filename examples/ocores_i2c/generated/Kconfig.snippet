## examples/ocores_i2c/generated/Kconfig.snippet
```kconfig
config OCORES_I2C
    bool
    select REGISTER
    select I2C
    select I2C_DEVICES
```
